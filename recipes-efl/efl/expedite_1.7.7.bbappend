RDEPENDS_${PN} = "expedite-themes evas-engine-fb evas-engine-software-x11 evas-engine-gl-x11 evas-loader-png"

